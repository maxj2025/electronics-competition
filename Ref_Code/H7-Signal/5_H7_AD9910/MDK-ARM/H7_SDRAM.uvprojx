# Keil uVision project H7_SDRAM.uvprojx, settings and files
target H7_SDRAM (6160000::V6.16::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7_SDRAM +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../bsp;../app;../long_fft
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: H7_SDRAM\H7_SDRAM.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fmc.c octospi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ospi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group bsp
    ../bsp/: bsp.c bsp.h bsp_sdram.c bsp_sdram.h bspsysteam.h qspi.c qspi.h norflash.c norflash.h test_demo.c test_demo.h
  group app
    ../app/: usart_app.c usart_app.h scheduler.c scheduler.h adc_app.c adc_app.h blue_app.c blue_app.h fft_app.c fft_app.h AD9910.c AD9910.h dpll.c dpll.h freq_measure.c freq_measure.h
  group long_fft
    ../long_fft/: arm_bitreversal2_extra.c arm_cfft_f32_extra.c arm_cfft_init_f32_extra.c arm_common_tables_extra.c arm_common_tables_extra.h arm_const_structs_extra.c arm_const_structs_extra.h arm_cortexM7l_math.lib arm_rfft_fast_f32_extra.c arm_rfft_fast_init_f32_extra.c extra_ffts.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
