# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Libraries\STM32H7xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\Libraries\FatFs\src; ..\..\Libraries\FatFs\src\drivers; ..\..\CANopen\CANopenNode; ..\..\CANopen\CANopenNode_STM32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_msg.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_can.c bsp_dwt.c bsp_fmc_io.c bsp_key.c bsp_led.c bsp_sdio_sd.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
  group CANopen
    ../../CANopen/CANopenNode/: CANopen.c CANopen.h
  group CANopen/301
    ../../CANopen/CANopenNode/301/: CO_config.h CO_driver.h CO_Emergency.c CO_Emergency.h CO_fifo.c CO_fifo.h CO_HBconsumer.c CO_HBconsumer.h CO_NMT_Heartbeat.c CO_NMT_Heartbeat.h CO_ODinterface.c CO_ODinterface.h CO_PDO.c CO_PDO.h CO_SDOclient.c CO_SDOclient.h CO_SDOserver.c CO_SDOserver.h CO_SYNC.c CO_SYNC.h CO_TIME.c CO_TIME.h crc16-ccitt.c crc16-ccitt.h
  group CANopen/303
    ../../CANopen/CANopenNode/303/: CO_LEDs.c CO_LEDs.h
  group CANopen/304
    ../../CANopen/CANopenNode/304/: CO_GFC.c CO_GFC.h CO_SRDO.c CO_SRDO.h
  group CANopen/305
    ../../CANopen/CANopenNode/305/: CO_LSS.h CO_LSSmaster.c CO_LSSmaster.h CO_LSSslave.c CO_LSSslave.h
  group CANopen/309
    ../../CANopen/CANopenNode/309/: CO_gateway_ascii.c CO_gateway_ascii.h
  group CANopen/extra
    ../../CANopen/CANopenNode/extra/: CO_trace.c CO_trace.h
  group CANopen/STM32
    ../../CANopen/CANopenNode_STM32/: CO_app_STM32.c CO_app_STM32.h CO_driver_STM32.c CO_driver_target.h CO_storageBlank.c CO_storageBlank.h main.h OD.c OD.h
  group CANopen/Storage
    ../../CANopen/CANopenNode/storage/: CO_eeprom.h CO_storage.c CO_storage.h CO_storageEeprom.c CO_storageEeprom.h
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_gpio.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group User
    ../../User/: can_network.c demo_canfd.c main.c
