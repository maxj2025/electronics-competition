# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::D:\Keil_v530\ARM\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\Libraries\FatFs\src;..\..\Libraries\FatFs\src\drivers;..\..\CANopen\CANopenNode;..\..\CANopen\CANopenNode_STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c demo_canfd.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_msg.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_can.c bsp_key.c bsp_timer.c bsp_beep.c bsp_sdio_sd.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_fdcan.c
    ../../../../V7-087_FDCAN/Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group FatFS
    ../../Libraries/FatFs/src/: ff.c ffconf.h diskio.c ff_gen_drv.c
    ../../Libraries/FatFs/src/option/: syscall.c cc936.c
    ../../Libraries/FatFs/src/drivers/: sd_diskio_dma.c
  group CANopen/301
    ../../CANopen/CANopenNode/301/: CO_config.h CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
  group CANopen/303
    ../../CANopen/CANopenNode/303/: CO_LEDs.c
  group CANopen/304
    ../../CANopen/CANopenNode/304/: CO_GFC.c CO_SRDO.c
  group CANopen/305
    ../../CANopen/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
  group CANopen/309
    ../../CANopen/CANopenNode/309/: CO_gateway_ascii.c
  group CANopen/extra
    ../../CANopen/CANopenNode/extra/: CO_trace.c
  group CANopen/Storage
    ../../CANopen/CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
  group CANopen
    ../../CANopen/CANopenNode/: CANopen.c
  group CANopen/STM32
    ../../CANopen/CANopenNode_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
