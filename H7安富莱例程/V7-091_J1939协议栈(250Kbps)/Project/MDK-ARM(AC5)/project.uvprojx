# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::D:\Keil_v530\ARM\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\Libraries\FatFs\src;..\..\Libraries\FatFs\src\drivers;..\..\J1939;..\..\J1939\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c demo_canfd.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_msg.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_can.c bsp_key.c bsp_timer.c bsp_beep.c bsp_sdio_sd.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_fdcan.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group FatFS
    ../../Libraries/FatFs/src/: ff.c ffconf.h diskio.c ff_gen_drv.c
    ../../Libraries/FatFs/src/option/: syscall.c cc936.c
    ../../Libraries/FatFs/src/drivers/: sd_diskio_dma.c
  group SAEJ1939/Port
    ../../J1939/Src/Hardware/: Hardware.h Save_Load_Struct.c CAN_Transmit_Receive.c FLASH_EEPROM_RAM_Memory.c
  group SAEJ1939/ISO11783
    ../../J1939/Src/ISO_11783/ISO_11783_Enums/: Enum_Valves.h
    ../../J1939/Src/ISO_11783/ISO_11783-7_Application_Layer/: Application_Layer.h Auxiliary_Valve_Command.c Auxiliary_Valve_Estimated_Flow.c Auxiliary_Valve_Measured_Position.c General_Purpose_Valve_Command.c General_Purpose_Valve_Estimated_Flow.c
  group SAE1939/Pro
    ../../J1939/Src/Open_SAE_J1939/: Structs.h C89_Library.h Open_SAE_J1939.h Startup_ECU.c Closedown_ECU.c Listen_For_Messages.c
  group SAE1939/Enums
    ../../J1939/Src/SAE_J1939/SAE_J1939_Enums/: Enum_NAME.h Enum_PGN.h Enum_Control_Byte.h Enum_DM1_DM2.h Enum_DM14_DM15.h Enum_Send_Status.h Enum_Group_Function_Value.h
  group SAEJ1939-21/Transport_Layer
    ../../J1939/Src/SAE_J1939/SAE_J1939-21_Transport_Layer/: Transport_Layer.h Request.c Acknowledgement.c Transport_Protocol_Connection_Management.c Transport_Protocol_Data_Transfer.c
  group SAEJ1939-71/Application_Layer
    ../../J1939/Src/SAE_J1939/SAE_J1939-71_Application_Layer/: Application_Layer.h Request_Proprietary.c Request_ECU_Identification.c Request_Software_Identification.c Request_Component_Identification.c
  group SAEJ1939-73/Diagnostics_Layer
    ../../J1939/Src/SAE_J1939/SAE_J1939-73_Diagnostics_Layer/: Diagnostics_Layer.h DM1.c DM2.c DM3.c DM14.c DM15.c DM16.c
  group SAE_J1939-81/Network_Management_Layer
    ../../J1939/Src/SAE_J1939/SAE_J1939-81_Network_Management_Layer/: Network_Management_Layer.h Address_Claimed.c Address_Delete.c Address_Not_Claimed.c Commanded_Address.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
