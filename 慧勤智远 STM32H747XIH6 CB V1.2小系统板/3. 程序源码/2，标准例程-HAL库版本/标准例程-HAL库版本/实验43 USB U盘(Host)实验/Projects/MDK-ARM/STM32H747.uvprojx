# Keil uVision project STM32H747.uvprojx, settings and files
target USBH_MSC (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H747 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H747xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,USE_USB_FS
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers;..\..\Middlewares;..\..\User;..\..\Middlewares\USB\STM32_USB_Host_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\..\Middlewares\USB\USB_APP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c tft_spi.c mipi_lcd.c
    ../../Drivers/BSP/QSPI/: qspi.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
    ../../Drivers/BSP/SDNAND/: sdmmc_sdnand.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USB_APP
    ../../Middlewares/USB/USB_APP/: usbh_conf.c usbh_diskio.c
  group Readme
    ../../: readme.txt
