# Keil uVision project STM32H747.uvprojx, settings and files
target DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H747 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H747xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers;..\..\Middlewares;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/IF_PORT/: if_port.c
    ../../Drivers/BSP/LT758/: LT758.c
    ../../Drivers/BSP/LT758_Lib/: LT758_Lib.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c touch.c gt9xxx.c ft5206.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/LT758_Function/: LT758_Function.c
    ../../Drivers/BSP/LT758_W25QXX/: LT758_W25QXX.c
    ../../Drivers/BSP/LT758_Draw_Font/: LT758_Draw_Font.c
  group Readme
    ../../: readme.txt
