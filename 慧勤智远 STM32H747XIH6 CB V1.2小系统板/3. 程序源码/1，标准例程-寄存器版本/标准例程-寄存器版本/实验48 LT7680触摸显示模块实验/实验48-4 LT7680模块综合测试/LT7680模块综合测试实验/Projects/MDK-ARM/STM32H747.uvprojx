# Keil uVision project STM32H747.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H747 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H747xx,USE_USB_FS
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Middlewares;..\..\User;..\..\User\APP;..\..\Middlewares\uC-OS2\uC-CPU\Cfg\Template;..\..\Middlewares\uC-OS2\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-CPU;..\..\Middlewares\uC-OS2\uC-LIB\Cfg\Template;..\..\Middlewares\uC-OS2\uC-LIB;..\..\Middlewares\uC-OS2\uC-OS2\Cfg\Template;..\..\Middlewares\uC-OS2\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-OS2\Source;..\..\Middlewares\AUDIOCODEC\wav;..\..\Middlewares\AUDIOCODEC\flac;..\..\Middlewares\AUDIOCODEC\flac\flacdec;..\..\Middlewares\AUDIOCODEC\mp3;..\..\Middlewares\AUDIOCODEC\mp3\helix;..\..\Middlewares\AUDIOCODEC\ape;..\..\Middlewares\AUDIOCODEC\ape\apedec;..\..\Middlewares\GUI;..\..\Middlewares\MJPEG\JPEG;..\..\Middlewares\NES;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\HID\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\..\Middlewares\USB\USB_APP;..\..\Middlewares\USB\USB_HAL;..\..\Middlewares\LWIP;..\..\Middlewares\LWIP\arch;..\..\Middlewares\LWIP\lwip-1.4.1\src\include;..\..\Middlewares\LWIP\lwip-1.4.1\src\include\ipv4;..\..\Middlewares\LWIP\lwip-1.4.1\src\include\lwip;..\..\Middlewares\LWIP\lwip-1.4.1\src\include\netif;..\..\Middlewares\LWIP\lwip_app\lwip_comm;..\..\Middlewares\LWIP\lwip_app\tcp_server_demo;..\..\Middlewares\LWIP\lwip_app\udp_demo;..\..\Middlewares\LWIP\lwip_app\web_server_demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
  group User
    ../../User/: main.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c tft_spi.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SPBLCD/: spblcd.c
    ../../Drivers/BSP/QSPI/: qspi.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
    ../../Drivers/BSP/SDNAND/: sdmmc_sdnand.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c touch.c gt9xxx.c ft5206.c
    ../../Drivers/BSP/DCMI/: dcmi.c
    ../../Drivers/BSP/OV2640/: sccb.c ov2640.c
    ../../Drivers/BSP/JPEGCODEC/: jpegcodec.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/ADC/: adc.c adc3.c
    ../../Drivers/BSP/IF_PORT/: if_port.c
    ../../Drivers/BSP/LT768/: LT768.c
    ../../Drivers/BSP/LT768_Lib/: LT768_Lib.c
    ../../Drivers/BSP/LT768_Demo/: LT768_Demo.c
  group User/APP
    ../../User/APP/: spb.c common.c ebook.c picviewer.c audioplay.c lyric.c videoplay.c calendar.c settings.c nesplay.c notepad.c exeplay.c paint.c camera.c recorder.c usbplay.c netplay.c wirelessplay.c calculator.c appplay.c keyplay.c ledplay.c vmeterplay.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c hjpgd.c
  group Middlewares/GUI
    ../../Middlewares/GUI/: button.c edit.c filelistbox.c gui.c listbox.c memlcd.c memo.c progressbar.c scrollbar.c window.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/uC-OS2/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/uC-OS2/uC-CPU/: cpu_core.c
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/uC-OS2/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/uC-OS2/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_dbg.c os_cpu_a.asm
    ../../Middlewares/uC-OS2/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middlewares/AUDIOCODEC/WAV
    ../../Middlewares/AUDIOCODEC/wav/: wavplay.c
  group Middlewares/AUDIOCODEC/MP3
    ../../Middlewares/AUDIOCODEC/mp3/: mp3play.c
    ../../Middlewares/AUDIOCODEC/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../../Middlewares/AUDIOCODEC/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group Middlewares/AUDIOCODEC/FLAC
    ../../Middlewares/AUDIOCODEC/flac/: flacplay.c
    ../../Middlewares/AUDIOCODEC/flac/flacdec/: bitstreamf.c flacdecoder.c tables.c
  group Middlewares/AUDIOCODEC/APE
    ../../Middlewares/AUDIOCODEC/ape/: apeplay.c
    ../../Middlewares/AUDIOCODEC/ape/apedec/: apedecoder.c entropy.c filter_16_11.c filter_32_10.c filter_64_11.c parser.c predictor.c predictor-arm.S
  group Middlewares/MJPEG
    ../../Middlewares/MJPEG/: avi.c mjpeg.c
  group Middlewares/NES
    ../../Middlewares/NES/: nes_apu.c nes_crc32.c nes_main.c nes_mapper.c nes_ppu.c 6502.s
  group Middlewares/T9INPUT
    ../../Middlewares/T9INPUT/: pyinput.c t9input.c
  group Middlewares/ATKNCR
    ../../Middlewares/ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
    ../../Middlewares/USB/USB_APP/: usbh_hid_gamepad.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USB_APP
    ../../Middlewares/USB/USB_APP/: usb_app.c usbd_conf.c usbd_desc.c usbd_storage.c usbh_conf.c usbh_diskio.c
  group Middlewares/USB_HAL
    ../../Middlewares/USB/USB_HAL/: stm32h7xx_hal_hcd.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Middlewares/LWIP/src/core
    ../../Middlewares/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Middlewares/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LWIP/src/api
    ../../Middlewares/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LWIP/src/netif
    ../../Middlewares/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group Middlewares/LWIP/arch
    ../../Middlewares/LWIP/arch/: sys_arch.c
  group Middlewares/LWIP/lwip_app
    ../../Middlewares/LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../Middlewares/LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group Readme
    ../../: readme.txt
