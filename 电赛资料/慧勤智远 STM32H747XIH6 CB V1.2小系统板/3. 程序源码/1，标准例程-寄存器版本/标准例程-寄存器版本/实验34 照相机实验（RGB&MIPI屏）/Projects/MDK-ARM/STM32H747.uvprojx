# Keil uVision project STM32H747.uvprojx, settings and files
target CAMERA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H747 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H747xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Middlewares;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
  group User
    ../../User/: main.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c tft_spi.c mipi_lcd.c
    ../../Drivers/BSP/DSI/: stm32h7xx_hal_dsi.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/DCMI/: dcmi.c
    ../../Drivers/BSP/OV2640/: sccb.c ov2640.c
    ../../Drivers/BSP/QSPI/: qspi.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
    ../../Drivers/BSP/SDNAND/: sdmmc_sdnand.c
    ../../Drivers/BSP/JPEGCODEC/: jpegcodec.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c hjpgd.c
  group Readme
    ../../: readme.txt
